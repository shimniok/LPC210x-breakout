<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UART.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>UART</project>
        <configuration>Jlink - Debug Flash</configuration>
      </member>
      <member>
        <project>UART</project>
        <configuration>Jlink - Debug RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


