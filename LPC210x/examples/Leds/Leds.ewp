# IAR project Leds.ewp, settings and files
configuration Jlink - Debug Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FLASH
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Leds.hex
  ILINK.IlinkOutputFile: Leds.out
  ILINK.IlinkIcfFile: config\LPC2103_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Jlink - Debug RAM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkIcfFile: config\LPC2103_RAM.icf
  group (top)
    ./: lpc2xxx_cstartup.s main.c
